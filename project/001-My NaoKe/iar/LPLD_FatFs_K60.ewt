<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>RAM</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>FLASH</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>BOOT</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>app</name>
    <file>
      <name>$PROJ_DIR$\..\app\k60_card.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\app\LPLD_FatFs.c</name>
    </file>
  </group>
  <group>
    <name>lib</name>
    <group>
      <name>common</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\common\alloc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\common\assert.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\common\assert.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\common\common.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\common\io.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\common\io.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\common\printf.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\common\queue.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\common\queue.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\common\relocate.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\common\relocate.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\common\stdlib.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\common\stdlib.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\common\uif.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\common\uif.h</name>
      </file>
    </group>
    <group>
      <name>CPU</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\CPU\MK60DZ10.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\CPU\startup_K60.s</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\CPU\system_MK60DZ10.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\CPU\system_MK60DZ10.h</name>
      </file>
    </group>
    <group>
      <name>FatFs</name>
      <group>
        <name>option</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\lib\FatFs\option\cc936.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\lib\FatFs\option\syscall.c</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\FatFs\diskio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\FatFs\diskio.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\FatFs\ff.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\FatFs\ff.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\FatFs\ffconf.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\FatFs\integer.h</name>
      </file>
    </group>
    <group>
      <name>LPLD</name>
      <group>
        <name>DEV</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\lib\LPLD\DEV\DEV_LCD.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\lib\LPLD\DEV\DEV_LCD.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\app\huatu.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\app\huatu.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\app\jianmian.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\app\jianmian.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\app\LQ12864.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\app\LQ12864.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\app\saolei.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\app\saolei.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\app\tuixiangzi.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\app\tuixiangzi.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\app\wuziqi.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\app\wuziqi.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\app\yingjian.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\app\yingjian.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\app\input.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\app\input.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\app\app_state.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\app\app_state.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\config\board_config.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\config\feature_config.h</name>
        </file>
      </group>
      <group>
        <name>HW</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\lib\LPLD\HW\HW_ADC.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\lib\LPLD\HW\HW_ADC.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\lib\LPLD\HW\HW_CAN.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\lib\LPLD\HW\HW_CAN.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\lib\LPLD\HW\HW_DAC.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\lib\LPLD\HW\HW_DAC.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\lib\LPLD\HW\HW_DMA.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\lib\LPLD\HW\HW_DMA.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\lib\LPLD\HW\HW_ENET.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\lib\LPLD\HW\HW_ENET.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\lib\LPLD\HW\HW_FLASH.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\lib\LPLD\HW\HW_FLASH.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\lib\LPLD\HW\HW_FLEXBUS.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\lib\LPLD\HW\HW_FLEXBUS.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\lib\LPLD\HW\HW_FTM.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\lib\LPLD\HW\HW_FTM.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\lib\LPLD\HW\HW_GPIO.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\lib\LPLD\HW\HW_GPIO.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\lib\LPLD\HW\HW_I2C.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\lib\LPLD\HW\HW_I2C.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\lib\LPLD\HW\HW_LPTMR.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\lib\LPLD\HW\HW_LPTMR.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\lib\LPLD\HW\HW_MCG.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\lib\LPLD\HW\HW_MCG.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\lib\LPLD\HW\HW_PDB.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\lib\LPLD\HW\HW_PDB.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\lib\LPLD\HW\HW_PIT.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\lib\LPLD\HW\HW_PIT.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\lib\LPLD\HW\HW_RTC.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\lib\LPLD\HW\HW_RTC.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\lib\LPLD\HW\HW_SDHC.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\lib\LPLD\HW\HW_SDHC.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\lib\LPLD\HW\HW_SPI.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\lib\LPLD\HW\HW_SPI.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\lib\LPLD\HW\HW_TSI.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\lib\LPLD\HW\HW_TSI.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\lib\LPLD\HW\HW_UART.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\lib\LPLD\HW\HW_UART.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\lib\LPLD\HW\HW_WDOG.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\lib\LPLD\HW\HW_WDOG.h</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\LPLD\LPLD_Drivers.h</name>
      </file>
    </group>
  </group>
</project>


